<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.2.1 AUTOSAR_00046.xsd" xmlns="http://autosar.org/schema/argh4.2.1" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
  </AR-PACKAGES>
</AUTOSAR>
