VERSION "HIPBNYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYYY/4/%%%/4/'%**4YYY///"

BS_:

BU_: Node TestNode


BO_ 1024 Message1: 5 TestNode

BO_ 1025 Message2: 0 TestNode




